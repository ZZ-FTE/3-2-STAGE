# Keil uVision project LCD1602.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Flibrary\inc;..\startup;..\user;..\user\api
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../Flibrary/src/: stm32f10x_flash.c stm32f10x_pwr.c
    ../user/: stm32f10x_it.c system_stm32f10x.c
  group api
    ../user/api/: delay.c delay.h io_bit.h ds18b20.c OLED_I2C.c
    ../user/: main.c
  group startup
    ../startup/: startup_stm32f10x_md.s
  group Flibrary
    ../Flibrary/src/: misc.c stm32f10x_crc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_bkp.c
software components: CMSIS:CORE 3.40.0
